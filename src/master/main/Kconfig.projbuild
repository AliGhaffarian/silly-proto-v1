## src/master/main/Kconfig.projbuild
```kconfig
menu "master configs"
    config SLAVES_NUM
        int "Number of slaves"
        default 1
endmenu
```
